# IAR project USB_RF.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: $PROJ_DIR$; F:\USB_RF\source; F:\USB_RF\startup; F:\USB_RF\CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_RF.srec
  ILINK.IlinkOutputFile: USB_RF.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source
    ../source/: CLOCK.c CLOCK.h FLASH.c FLASH.h GPIO.c GPIO.h main.c nRF24L01.c nRF24L01.h SPI.c SPI.h TIMER.c TIMER.h USB.c USB.h USB_HID.h USB_HW.c USB_HW.h USB_Types.h
  group startup
    ../startup/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
